DESCRIPTION = "System development image with XFCE and the SDK"
LICENSE = "MIT"

require systemdev-image-xfce.bb
require systemdev-sdk.inc
