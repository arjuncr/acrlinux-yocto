DESCRIPTION = "System development image with SDK"
LICENSE = "MIT"

require systemdev-image.bb
require systemdev-sdk.inc
