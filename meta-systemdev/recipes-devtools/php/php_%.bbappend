# we do not need imap or pam support that is enabled by default
PACKAGECONFIG = "mysql sqlite3"
