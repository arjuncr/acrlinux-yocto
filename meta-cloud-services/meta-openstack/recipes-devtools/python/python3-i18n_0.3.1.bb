require python-i18n.inc
inherit setuptools3
