require python-xstatic-jquery.inc
inherit setuptools3
