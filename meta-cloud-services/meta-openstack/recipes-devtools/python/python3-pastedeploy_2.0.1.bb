require python-pastedeploy.inc
inherit setuptools3
