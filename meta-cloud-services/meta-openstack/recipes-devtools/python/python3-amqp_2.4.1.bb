inherit setuptools3
require python-amqp.inc
