inherit setuptools3
require python-httpretty.inc

