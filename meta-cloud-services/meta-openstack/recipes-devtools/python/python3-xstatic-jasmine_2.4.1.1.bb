require python-xstatic-jasmine.inc
inherit setuptools3
