inherit setuptools3
require python-rfc3986.inc
