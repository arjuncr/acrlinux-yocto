inherit setuptools3
require python-osc-lib.inc
