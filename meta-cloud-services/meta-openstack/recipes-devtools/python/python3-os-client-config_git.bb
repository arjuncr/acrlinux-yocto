inherit setuptools3
require python-os-client-config.inc
