inherit setuptools3
require python-warlock.inc

