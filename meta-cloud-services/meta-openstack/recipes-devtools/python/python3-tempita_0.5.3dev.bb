require python-tempita.inc
inherit setuptools3
