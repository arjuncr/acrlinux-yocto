require python-testrepository.inc
inherit setuptools3

