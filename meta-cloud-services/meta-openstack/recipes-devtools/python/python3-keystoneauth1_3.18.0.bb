inherit setuptools3
require python-keystoneauth1.inc
