inherit setuptools3
require python-kombu.inc
