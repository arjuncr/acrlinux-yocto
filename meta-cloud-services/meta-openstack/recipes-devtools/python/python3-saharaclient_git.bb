require python-saharaclient.inc
inherit setuptools3
