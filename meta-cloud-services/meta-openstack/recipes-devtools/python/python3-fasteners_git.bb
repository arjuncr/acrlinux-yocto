inherit setuptools3
require python-fasteners.inc
