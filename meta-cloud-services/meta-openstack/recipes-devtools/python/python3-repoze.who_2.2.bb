require python-repoze.who.inc
inherit setuptools3
