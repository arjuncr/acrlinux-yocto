inherit setuptools3
require python-setuptools-git.inc
