require python-gevent-websocket.inc
inherit setuptools3
