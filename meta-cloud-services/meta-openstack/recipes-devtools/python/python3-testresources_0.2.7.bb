require python-testresources.inc
inherit setuptools3
