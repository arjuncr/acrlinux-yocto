require python-coverage.inc
inherit setuptools3
