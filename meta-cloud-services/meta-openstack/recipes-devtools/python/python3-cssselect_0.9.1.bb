require python-cssselect.inc
inherit setuptools3
