require python-memcache.inc
inherit setuptools3
