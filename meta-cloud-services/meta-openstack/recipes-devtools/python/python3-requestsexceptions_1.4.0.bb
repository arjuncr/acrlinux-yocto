inherit setuptools3
require python-requestsexceptions.inc
