inherit setuptools3
require python-pecan.inc
