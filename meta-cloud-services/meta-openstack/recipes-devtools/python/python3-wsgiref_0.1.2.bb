require python-wsgiref.inc
inherit setuptools3
