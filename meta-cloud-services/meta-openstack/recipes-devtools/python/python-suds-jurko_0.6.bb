inherit setuptools3
require python-suds-jurko.inc

