require python-xstatic-angular-bootstrap.inc
inherit setuptools3
