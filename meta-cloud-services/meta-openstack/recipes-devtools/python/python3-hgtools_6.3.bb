require python-hgtools.inc
inherit setuptools3
