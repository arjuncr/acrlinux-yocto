require python-kafka.inc
inherit setuptools3

