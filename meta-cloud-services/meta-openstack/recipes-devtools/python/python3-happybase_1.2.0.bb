inherit setuptools3
require python-happybase.inc
