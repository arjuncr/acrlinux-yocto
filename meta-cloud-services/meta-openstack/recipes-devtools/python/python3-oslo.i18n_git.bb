inherit setuptools3
require python-oslo.i18n.inc
