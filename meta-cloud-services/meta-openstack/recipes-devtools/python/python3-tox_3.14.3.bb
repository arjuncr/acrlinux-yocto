inherit setuptools3
require python-tox.inc

SRC_URI[md5sum] = "8b695d482786dd51643e10953bbd8c89"
SRC_URI[sha256sum] = "06ba73b149bf838d5cd25dc30c2dd2671ae5b2757cf98e5c41a35fe449f131b3"
