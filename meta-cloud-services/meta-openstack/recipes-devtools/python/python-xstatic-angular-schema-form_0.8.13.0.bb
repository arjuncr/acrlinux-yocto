require python-xstatic-angular-schema-form.inc
inherit setuptools3
