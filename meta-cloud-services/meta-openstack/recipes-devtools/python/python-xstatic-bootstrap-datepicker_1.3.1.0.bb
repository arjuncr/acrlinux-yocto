require python-xstatic-bootstrap-datepicker.inc
inherit setuptools3
