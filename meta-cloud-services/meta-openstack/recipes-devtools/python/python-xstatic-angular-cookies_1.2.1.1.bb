require python-xstatic-angular-cookies.inc
inherit setuptools3
