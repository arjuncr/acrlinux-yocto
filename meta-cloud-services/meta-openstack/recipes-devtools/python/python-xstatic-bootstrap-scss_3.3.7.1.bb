require python-xstatic-bootstrap-scss.inc
inherit setuptools3
