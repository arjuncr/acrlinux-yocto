inherit setuptools3
require python-amqplib.inc
