require python-pysnmp.inc
inherit setuptools3
