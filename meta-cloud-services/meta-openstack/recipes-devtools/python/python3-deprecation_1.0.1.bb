require python-deprecation.inc
inherit setuptools3
