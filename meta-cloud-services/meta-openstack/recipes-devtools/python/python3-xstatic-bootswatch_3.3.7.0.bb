require python-xstatic-bootswatch.inc
inherit setuptools3
