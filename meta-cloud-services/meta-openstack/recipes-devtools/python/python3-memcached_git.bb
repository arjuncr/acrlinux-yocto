require python-memcached.inc
inherit setuptools3
