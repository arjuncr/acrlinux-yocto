require python-ordereddict.inc
inherit setuptools3
