require python-pytest-salt.inc
inherit setuptools3
