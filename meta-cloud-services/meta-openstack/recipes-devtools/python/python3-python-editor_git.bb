require python-python-editor.inc
inherit setuptools3
