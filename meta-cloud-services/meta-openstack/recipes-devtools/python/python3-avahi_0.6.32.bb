require python-avahi.inc

inherit python3-dir

RDEPENDS_${PN} += "python3-core python3-dbus"
