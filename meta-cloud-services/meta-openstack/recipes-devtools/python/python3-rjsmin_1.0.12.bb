require python-rjsmin.inc
inherit setuptools3
