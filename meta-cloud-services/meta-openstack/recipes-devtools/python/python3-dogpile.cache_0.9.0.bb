inherit setuptools3
require python-dogpile.cache.inc


