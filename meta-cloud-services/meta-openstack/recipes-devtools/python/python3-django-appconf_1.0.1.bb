require python-django-appconf.inc
inherit setuptools3
