require python-xstatic-font-awesome.inc
inherit setuptools3
