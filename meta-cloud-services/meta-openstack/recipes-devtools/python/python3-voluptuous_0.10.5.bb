require python-voluptuous.inc
inherit setuptools3
