require python-cephclient.inc
inherit setuptools3
