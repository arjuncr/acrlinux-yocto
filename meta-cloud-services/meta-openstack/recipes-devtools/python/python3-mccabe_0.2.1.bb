require python-mccabe.inc
inherit setuptools3
