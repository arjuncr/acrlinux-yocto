inherit setuptools3
require python-vine.inc

