require python-paste.inc
inherit setuptools3
