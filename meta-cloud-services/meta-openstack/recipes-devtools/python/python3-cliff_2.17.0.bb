inherit setuptools3
require python-cliff.inc
