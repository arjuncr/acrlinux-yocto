require python-retrying.inc
inherit setuptools3
