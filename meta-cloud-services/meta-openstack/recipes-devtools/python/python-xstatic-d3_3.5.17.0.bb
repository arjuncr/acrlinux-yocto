require python-xstatic-d3.inc
inherit setuptools3
