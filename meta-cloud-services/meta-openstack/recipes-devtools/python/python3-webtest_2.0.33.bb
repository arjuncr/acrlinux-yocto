inherit setuptools3 pypi
require python-webtest.inc
