require python-uritemplate.inc
inherit setuptools3
