require python-semantic-version.inc
inherit setuptools3
