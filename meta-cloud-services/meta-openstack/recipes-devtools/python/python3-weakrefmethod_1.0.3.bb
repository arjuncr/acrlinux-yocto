require python-weakrefmethod.inc
inherit setuptools3
