require python-xstatic-angular-irdragndrop.inc
inherit setuptools3
