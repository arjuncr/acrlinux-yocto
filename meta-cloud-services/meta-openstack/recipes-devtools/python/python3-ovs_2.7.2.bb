require python-ovs.inc
inherit setuptools3
