inherit setuptools3 
require python-pika-pool.inc
