inherit setuptools3 pypi
require python-croniter.inc
