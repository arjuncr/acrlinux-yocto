require python-lesscpy.inc
inherit setuptools3
