require python-pam.inc
inherit setuptools3
