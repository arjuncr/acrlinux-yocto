inherit setuptools3
require python-enum-compat.inc
