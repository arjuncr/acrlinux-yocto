require python-thrift.inc
inherit setuptools3
