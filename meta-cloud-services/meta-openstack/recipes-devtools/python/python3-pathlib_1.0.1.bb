require python-pathlib.inc
inherit setuptools3
