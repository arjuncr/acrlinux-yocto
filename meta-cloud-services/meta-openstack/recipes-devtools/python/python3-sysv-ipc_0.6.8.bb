require python-sysv-ipc.inc
inherit setuptools3
