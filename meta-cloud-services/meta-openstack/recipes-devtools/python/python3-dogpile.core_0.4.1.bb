require python-dogpile.core.inc
inherit setuptools3


