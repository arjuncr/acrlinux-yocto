inherit setuptools3
require python-positional.inc
