inherit setuptools3
require python-eventlet.inc
