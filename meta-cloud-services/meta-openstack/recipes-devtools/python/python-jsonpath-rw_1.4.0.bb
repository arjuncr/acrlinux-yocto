require python-jsonpath-rw.inc
inherit setuptools3
