require python-pyflakes.inc
inherit setuptools3
