inherit setuptools3
require python-logutils.inc
