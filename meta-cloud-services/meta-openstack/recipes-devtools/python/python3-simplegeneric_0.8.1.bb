inherit setuptools3
require python-simplegeneric.inc 
