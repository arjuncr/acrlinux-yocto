require python-arrow.inc
inherit setuptools3
