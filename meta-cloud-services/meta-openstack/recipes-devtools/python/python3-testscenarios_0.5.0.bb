inherit setuptools3
require python-testscenarios.inc
