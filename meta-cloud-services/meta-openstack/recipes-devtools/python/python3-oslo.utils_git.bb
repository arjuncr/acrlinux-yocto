inherit setuptools3
require python-oslo.utils.inc
