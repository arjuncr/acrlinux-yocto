require python-funcsigs.inc
inherit setuptools3
