require python-xstatic-angular-gettext.inc
inherit setuptools3
