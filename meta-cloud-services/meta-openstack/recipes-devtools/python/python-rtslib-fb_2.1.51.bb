require python-rtslib-fb.inc
inherit setuptools3
