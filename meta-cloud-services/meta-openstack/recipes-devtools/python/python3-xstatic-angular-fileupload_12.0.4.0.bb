require python-xstatic-angular-fileupload.inc
inherit setuptools3
