require python-xstatic-jquery-migrate.inc
inherit setuptools3
