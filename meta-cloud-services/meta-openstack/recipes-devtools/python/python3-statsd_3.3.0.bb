inherit setuptools3
require python-statsd.inc
