require python-xstatic-hogan.inc
inherit setuptools3
