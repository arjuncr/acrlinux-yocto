require python-rcssmin.inc
inherit setuptools3
