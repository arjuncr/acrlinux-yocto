require python-colorama.inc
inherit setuptools3

