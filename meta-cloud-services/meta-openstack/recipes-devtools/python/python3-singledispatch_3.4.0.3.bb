require python-singledispatch.inc
inherit setuptools3
