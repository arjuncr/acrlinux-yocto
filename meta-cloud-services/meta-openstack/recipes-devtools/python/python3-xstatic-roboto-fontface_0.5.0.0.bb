require python-xstatic-roboto-fontface.inc
inherit setuptools3
