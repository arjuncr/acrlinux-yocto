inherit setuptools3
require python-posix-ipc.inc
