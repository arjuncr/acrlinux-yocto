inherit setuptools3
require python-debtcollector.inc
