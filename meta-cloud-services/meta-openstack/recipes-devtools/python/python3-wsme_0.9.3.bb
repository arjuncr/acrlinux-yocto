inherit setuptools3 pypi
require python-wsme.inc
