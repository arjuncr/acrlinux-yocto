PACKAGECONFIG_append_rk3288 = " kmsro panfrost"
PACKAGECONFIG_append_rk3399 = " kmsro panfrost"
