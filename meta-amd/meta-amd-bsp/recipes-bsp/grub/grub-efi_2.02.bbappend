RDEPENDS_${PN}_class-target_append = " efibootmgr"
export PYTHON
