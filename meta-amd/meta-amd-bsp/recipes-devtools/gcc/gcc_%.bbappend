FILES_${PN}_append_amd = "\
    ${bindir}/${TARGET_SYS}-${TARGET_PREFIX}gcc* \
    ${bindir}/${TARGET_SYS}-${TARGET_PREFIX}g++ \
"
